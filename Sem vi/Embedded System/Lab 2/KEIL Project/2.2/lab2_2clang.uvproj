# Keil uVision project lab2_2clang.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lab2_2clang +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../Codes/C/: lab_2_b.c
